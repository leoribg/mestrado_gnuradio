options:
  parameters:
    generate_options: no_gui
    id: power_final
    output_language: python
    realtime_scheduling: '1'
    title: Not titled yet
  states: {}

blocks:
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '50000'
    max_iter: '4000'
    scale: '20e-6'
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: bw
  id: parameter
  parameters:
    label: bw
    type: eng_float
    value: '200000'
  states: {}
- name: center_freq
  id: parameter
  parameters:
    label: center_freq
    type: eng_float
    value: '902200000'
  states: {}
- name: filename
  id: parameter
  parameters:
    label: filename
    type: str
    value: /home/leo/mestrado/teste.txt
  states: {}
- name: filerepeater_VectorToTxtFile_0
  id: filerepeater_VectorToTxtFile
  parameters:
    WriteTimeHeader: 'False'
    append: 'True'
    filename: filename
    frequency: '1'
    notes: ''
    precision: '2'
    sampleRate: samp_rate
    updateRateSec: '0.1'
    vectorsize: '1'
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: bw/2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: bw/10
    win: firdes.WIN_HAMMING
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    gain_dB_ch0: '40'
    oversample: '0'
    rf_freq: center_freq
    samp_rate: samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: bw/2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: bw/10
    win: firdes.WIN_HAMMING
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    type: eng_float
    value: '1000000'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', filerepeater_VectorToTxtFile_0, '0']
- [high_pass_filter_0, '0', low_pass_filter_0, '0']
- [limesdr_source_0, '0', high_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
